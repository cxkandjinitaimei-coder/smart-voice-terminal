# Keil uVision project STM32_Controller_OTA.uvprojx, settings and files
target STM32_Controller_OTA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08008000,0x00038000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32_Controller_OTA +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,CAMERA_FIFO_FAST_IO
  c include: ..\Core;..\Lib\inc;..\User;..\System;..\Hardware\02KEY;..\Hardware\06USART;..\Hardware\11DHT11;..\Hardware\13LEDPWM;..\Hardware\14ESP_UART;..\Hardware\15LCD;..\Hardware\16SD;..\Hardware\17PCA9685;..\Hardware\18INMP441;..\Hardware\19MICREC;..\Hardware\20MICAUD;..\Hardware\22W25Q;..\Hardware\21IAP;..\Hardware\23OV7725;..\System\FATFS;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group CORE
    ./: stm32f4xx_it.c system_stm32f4xx.c
    ../Core/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../System/: time.c
  group HARWARE
    ../Hardware/02KEY/: key.c
    ../Hardware/06USART/: uart.c
    ../Hardware/11DHT11/: dht11.c
    ../Hardware/13LEDPWM/: led_pwm.c
    ../Hardware/14ESP_UART/: esp_uart.c
    ../Hardware/15LCD/: lcd.c
    ../Hardware/16SD/: sd.c
    ../Hardware/17PCA9685/: pca9685.c pca9685_cmd.c
    ../Hardware/18INMP441/: inmp441.c
    ../Hardware/19MICREC/: micrec.c
    ../Hardware/20MICAUD/: micaud.c
    ../Hardware/22W25Q/: w25q.c w25q_selftest.c
    ../App/: camera_link.c
    ../Hardware/23OV7725/: camera_ov7725.c
    ../Hardware/21IAP/: iap_flash.c iap_meta.c iap_app.c
  group LIB
    ../Lib/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c
  group MEDIA
    ../System/FATFS/: ff.c diskio.c
    ../App/: face_anim.c robot_gui.c media.c ailink.c miclink.c font.c font_store.c font_upload.c w25q_img.c
    ../Hardware/06USART/: uart_rx.c
software components: CMSIS:CORE 5.5.0
