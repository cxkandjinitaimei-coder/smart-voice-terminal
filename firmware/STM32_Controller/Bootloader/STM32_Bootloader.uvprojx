# Keil uVision project STM32_Bootloader.uvprojx, settings and files
target STM32_Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32_Bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\Core;..\User;..\Lib\inc;..\Hardware\21IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\boot_layout.sct
  group USER
    ./: boot_main.c
  group CORE
    ../User/: system_stm32f4xx.c
    ../Core/: startup_stm32f40_41xxx.s
  group IAP
    ../Hardware/21IAP/: iap_flash.c iap_meta.c
  group LIB
    ../Lib/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
software components: CMSIS:CORE 5.5.0
